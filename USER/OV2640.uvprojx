# Keil uVision project OV2640.uvprojx, settings and files
target OV2640 (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OV2640 +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\DCMI;..\HARDWARE\TIMER;..\FWLIB\inc;..\USMART;..\CMSIS\Include;..\HARDWARE\EC20;..\HARDWARE\OV5640;..\HARDWARE\RTC;..\HARDWARE\WAKEUP;..\HARDWARE\SRAM;..\HARDWARE\PCF85163;..\HARDWARE\ADC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT8: RAM 0x68000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/DCMI/: dcmi.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/EC20/: EC20.c
    ../HARDWARE/OV5640/: ov5640.c sccb.c
    ../HARDWARE/WAKEUP/: wakeup.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/PCF85163/: iic.c pcf8563.c
    ../HARDWARE/ADC/: adc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_dcmi.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_dma.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_adc.c
